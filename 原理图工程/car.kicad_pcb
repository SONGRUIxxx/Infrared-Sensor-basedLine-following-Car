# Repository SONGRUIxxx/Infrared-Sensor-basedLine-following-Car

File README.md:

# 综合设计与实践A综合实验设计报告

## 摘要
本项目以 STM32G030C8T6 单片机为控制核心，设计并实现了一款集成传感器系统、电机驱动与电源管理的双轮迷宫机器鼠，旨在完成前进、后退、变速、转向、避障及巡线等功能。硬件上，采用 TPS5430DDAR 将 6V 输入电压转换为 3.3V 系统电压，通过两片 TC118S 驱动双电机，8 个 ITR20001 红外传感器（4 个避障、4 个巡线）均以 ADC 方式采集模拟信号以提升感知精度；软件上基于 PD 算法计算电机转速差，结合定时器 PWM 输出与 DMA 传输实现高效控制。经调试，确定 KP=0.14、KD=0.1 为最优控制参数，机器鼠可在白色 KT 板（20~25mm 黑色胶带）场景中稳定巡线，且能及时响应避障需求，所有电路集成于单块定制 PCB，满足项目技术指标。

---

## 一．题意分析
### 1. 项目背景
本项目旨在基于STM32G030C8T6单片机为核心控制器，设计并制作一个能够自主在迷宫中导航的双轮智能机器鼠。该机器鼠需集成传感器系统、电机驱动、电源管理于一体，最终实现包括前进、后退、变速、原地转向、行进转向、避障、巡线在内的完整运动控制功能。

项目要求所有电子电路均集成于一块自主设计的PCB之上，严禁使用现成的功能模块，以全面考察硬件设计、嵌入式软件编程及系统集成能力。

### 2. 主要技术指标
1. 主控芯片：STM32G030C8T6单片机。
2. 电源系统：6V输入，TPS5430DDAR降压至3.3V。
3. 电机驱动：两片TC118S独立驱动双轮。
4. 传感器系统：8个ITR20001红外传感器（4避障+4巡线，ADC采集）。
5. PCB设计：所有电路集成于一块定制PCB。

---

## 二．原理分析
### 1. 运动控制原理
两轮差速模型，通过调节左右轮转速差实现转向。

### 2. 红外传感原理
ITR20001集成红外发射与接收，反射强度转为电压，ADC采集用于避障与巡线。

### 3. PWM调速原理
STM32定时器输出PWM，经TC118S调速，实现电机连续可调。

### 4. 方案比较
- 红外读取：GPIO（二元）vs ADC（模拟量），选ADC。
- 运动算法：PID vs PD，选PD（简化、抑制震荡）。

---

## 三．电路实现
### 1. 原理图
（详见原理图工程文件夹）

### 2. 局部分析
- 单片机模块：PA0~PA7为ADC，PA8~PA11为PWM，PD2为调试LED。
- 红外模块：发射端串330R，接收端上拉10K。
- 电源：R1=10K，R2=5.9K设定3.3V输出。
- 电机驱动：TC118S控制双轮。

---

## 四．软件算法
### 1. 代码流程
- 初始化：GPIO、DMA、ADC、TIM。
- 启动PWM、ADC DMA。
- 主循环：
  - 检查adc_ready。
  - 若有障碍物（adc[0~3]<阈值）：亮LED，调用bizhang()避障。
  - 否则：
    - 计算averange=adc[4]+adc[5]-adc[6]-adc[7]。
    - PD算法计算speed=KP*averange+KD*(averange-averange_last)。
    - 限幅后调用move(speed)。
  - 20ms周期。

### 2. 关键参数
- KP=0.14，KD=0.1。

---

## 五．测试方法、结果与分析
- 硬件确认、场景搭建。
- 调试顺序：先KP后KD，目标为无偏移巡线、平滑过弯、及时避障。
- 最终参数下，机器鼠在标准场景下表现稳定。

---

## 六．总结
- 硬件集成化，电路布局合理。
- 采用ADC采集提升感知精度。
- PD算法简化控制，满足动态性能。

---

## 附录A：电路原理图及PCB
详见原理图工程文件夹。

## KiCad design 原理图工程/car.kicad_pcb

Parts:
C1: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C10, C11: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C7: 100uF; CP_Elec_6.3x5.4
C5: 4.7uF; CP_Elec_6.3x5.4
C6: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C9: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: LED; LED_0805_2012Metric
D3: SS34; D_SMA_Handsoldering
J1: Conn_01x04_Pin; FanPinHeader_1x04_P2.54mm_Vertical
J2, J3, J4: Screw_Terminal_01x02; Altech_AK100_1x02_P5.00mm
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
L1: L; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
L2: IHLP2020CER220M11; L_6.3x6.3_H3
R1, R2, R3, R4, R5, R6, R7, R8, R9, R12: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R17, R18, R19, R20: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R22, R23, R24: R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W6.73mm_P2.54mm_LowProfile_J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
U1, U2, U3, U4, U5, U6, U7, U8: ITR20001/T24; Everlight_ITR20001
U9: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias
U10, U11: LP2988-5.0_SOIC8_VSSOP8; SOIC-8_3.9x4.9mm_P1.27mm
U12: STM32G030C8Tx; LQFP-48_7x7mm_P0.5mm

Connections:
+3.3V: C1.1, C7.1, J1.1, JP1.1 (A), L1.1, L2.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R10.1, R11.1, R12.1, R13.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, U12.4 (VBAT), U12.6 (VDD)
+6V: C4.1, C5.1, C8.1, C9.1, J2.1, U9.7 (VIN), U10.4 (GND), U11.4 (GND)
/CLK: J1.4, JP1.2 (B), R9.1, U12.36 (PA14)
/DIO: J1.3, U12.35 (PA13)
/ITR1: R1.1, U1.4 (C), U12.11 (PA0)
/ITR2: R2.1, U2.4 (C), U12.12 (PA1)
/ITR3: R3.1, U3.4 (C), U12.13 (PA2)
/ITR4: R4.1, U4.4 (C), U12.14 (PA3)
/ITR5: R5.1, U5.4 (C), U12.15 (PA4)
/ITR6: R6.1, U6.4 (C), U12.16 (PA5)
/ITR7: R7.1, U7.4 (C), U12.17 (PA6)
/ITR8: R8.1, U8.4 (C), U12.18 (PA7)
/LED2: D2.1 (K), U12.40 (PD2)
/PWM1A: U10.2 (~SHTD), U12.28 (PA8)
/PWM1B: U11.2 (~SHTD), U12.32 (PA10/NC)
/PWM2A: U10.3 (DELAY), U12.29 (PA9/NC)
/PWM2B: U11.3 (DELAY), U12.33 (PA11/PA9)
/REF: C2.1, L1.2, U12.5 (VREF+)
/RST: C3.1, R12.2, SW1.2, U12.10 (NRST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, D1.1 (K), D3.2 (A), J1.2, J2.2, R9.2, R16.2, SW1.1, U1.2 (K), U1.3 (E), U2.2 (K), U2.3 (E), U3.2 (K), U3.3 (E), U4.2 (K), U4.3 (E), U5.2 (K), U5.3 (E), U6.2 (K), U6.3 (E), U7.2 (K), U7.3 (E), U8.2 (K), U8.3 (E), U9.6 (GND), U9.9 (GNDPAD), U10.6 (~ERROR), U10.7 (SENSE), U11.6 (~ERROR), U11.7 (SENSE), U12.7 (VSS)
unnamed: D1.2 (A), R10.2
unnamed: D2.2 (A), R11.2
unnamed: C6.2, D3.1 (K), L2.1, U9.8 (PH)
unnamed: C10.1, J3.1, U10.8 (OUT)
unnamed: C10.2, J3.2, U10.5 (BP)
unnamed: C11.1, J4.1, U11.8 (OUT)
unnamed: C11.2, J4.2, U11.5 (BP)
unnamed: R14.2, R15.1
unnamed: R15.2, R16.1
unnamed: R17.2, U1.1 (A)
unnamed: R18.2, U2.1 (A)
unnamed: R19.2, U3.1 (A)
unnamed: R20.2, U4.1 (A)
unnamed: R21.2, U5.1 (A)
unnamed: R22.2, U6.1 (A)
unnamed: R23.2, U7.1 (A)
unnamed: R24.2, U8.1 (A)
unnamed: C6.1, U9.1 (BOOT)
unnamed: R13.2, R14.1, U9.4 (VSENSE)

Notes on the sheet:
单片机模块
电机驱动系统
6v转3v3电路
LED灯
红外模块
复位按键
烧录接口
SCBG160808U501T
参考电压

Board: 2 copper layers, 100.0 x 70.0 mm, 58 parts (4 on the bottom side), 39 nets.

## Code that names these connections

File 代码工程/carcar.ioc (part):

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Mcu.Name=STM32G030C(6-8)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32G030C8Tx
PA0.Signal=SharedAnalog_PA0
PA1.Signal=SharedAnalog_PA1
PA10.Signal=S_TIM1_CH3
PA11\ [PA9].Signal=S_TIM1_CH4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14-BOOT0.Mode=Serial_Wire
PA14-BOOT0.Signal=SYS_SWCLK
PA2.Signal=SharedAnalog_PA2
PA3.Signal=SharedAnalog_PA3
PA4.Signal=SharedAnalog_PA4
PA5.Signal=SharedAnalog_PA5
PA6.Signal=SharedAnalog_PA6
PA7.Signal=SharedAnalog_PA7
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PD2.GPIOParameters=PinState
PD2.PinState=GPIO_PIN_SET
PD2.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom
